# Keil uVision project CAN_Try.uvprojx, settings and files
target CAN (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAN_Try +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User;..\..\User\CAN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: ascii.h bsp_adc.c bsp_adc.h bsp_BH1750.c bsp_BH1750.h bsp_buzzer.c bsp_buzzer.h bsp_dht11.c bsp_dht11.h bsp_dht22.c bsp_dht22.h bsp_DS18B20.c bsp_DS18B20.h bsp_E18.c bsp_E18.h bsp_ili9341_lcd.c bsp_ili9341_lcd.h bsp_it.c bsp_it.h bsp_led.c bsp_led.h bsp_SysTick.c bsp_SysTick.h bsp_usart1.c bsp_usart1.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h bsp_bjdj.c bsp_pwm_output.c
    ../../User/CAN/: bsp_CAN.c bsp_CAN.h
