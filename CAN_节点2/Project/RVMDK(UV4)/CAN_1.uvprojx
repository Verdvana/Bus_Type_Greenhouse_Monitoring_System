# Keil uVision project CAN_1.uvprojx, settings and files
target CAN_2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAN_1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User\CAN;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c
  group USER
    ../../User/CAN/: bsp_CAN.c bsp_CAN.h
    ../../User/: ascii.h bsp_adc.c bsp_adc.h bsp_BH1750.c bsp_BH1750.h bsp_bjdj.c bsp_bjdj.h bsp_buzzer.c bsp_buzzer.h bsp_dht11.c bsp_dht11.h bsp_dht22.c bsp_dht22.h bsp_DS18B20.c bsp_DS18B20.h bsp_E18.c bsp_E18.h bsp_ili9341_lcd.c bsp_ili9341_lcd.h bsp_it.c bsp_it.h bsp_led.c bsp_led.h bsp_pwm_output.c bsp_pwm_output.h bsp_SysTick.c bsp_SysTick.h bsp_usart1.c bsp_usart1.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
